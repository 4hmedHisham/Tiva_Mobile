# IAR project asddsdvsdv.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: C:\Users\ShadowZone\Desktop\Moible.ya5ty3aleha\driverlib\gcc\libdriver.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: CalculatorMind.c CalculatorMind.h ContactList.c ContactList.h Game.c.c Game.h keypad.c keypad.h Lcd.c Lcd.h main.c rtc.c rtc.h Setup.h startup_ewarm.c tm4c123gh6pm.h
